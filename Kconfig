## Kconfig
```kconfig
config RTL8812AU
	tristate "Realtek 8812A USB WiFi"
	depends on USB
	help
	  Help message for RTL8812AU
```
